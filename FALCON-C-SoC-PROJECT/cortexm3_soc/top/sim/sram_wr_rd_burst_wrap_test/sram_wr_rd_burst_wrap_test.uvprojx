# Keil uVision project sram_wr_rd_burst_wrap_test.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: sram_wr_rd_burst_wrap_test
  AfterMake: fromelf -cvf .\Objects\sram_wr_rd_burst_wrap_test.axf --vhx --8x1 -o image.hex
  AfterMake: fromelf -cvf .\Objects\sram_wr_rd_burst_wrap_test.axf-o disasm.txt
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: first.c startup.s
